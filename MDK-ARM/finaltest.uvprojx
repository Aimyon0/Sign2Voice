# Keil uVision project finaltest.uvprojx, settings and files
target finaltest (6110000::V6.11::.\ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: finaltest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;./HARDWARE/TIMER;../X-CUBE-AI/App;../X-CUBE-AI;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LVGL;../Middlewares/Third_Party/LVGL/include/lvgl;./HARDWARE/MP3;../Middlewares/ST/AI/Inc;../Drivers/CMSIS/Include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: finaltest.sct
  link misc: --cpp
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: lv_port_disp.c lv_port_indev.c lv_port_tick.c ui_overlay.c camera_band_refresh.c main.c gpio.c freertos.c dma.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group hardware
    ./HARDWARE/TIMER/: timer.c delay.c led.c key.c mpu.c GBK_LibDrive.c
    ./: system.c
    ./HARDWARE/MP3/: mp3.c mp3.h
  group LCD
    ./HARDWARE/TIMER/: FONT.c Picture.c Text.c Dis_Picture.c lcd.c
  group ov2640
    ./HARDWARE/TIMER/: dcmi.c stm32h7xx_hal_dcmi.c sccb.c ov2640.c OV_Frame.c usart2.c
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: gesture_finetuned.c gesture_finetuned_data.c gesture_finetuned_data_params.c app_x-cube-ai.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL
    ../Middlewares/Third_Party/LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../Middlewares/Third_Party/LVGL/src/display/: lv_display.c
    ../Middlewares/Third_Party/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../Middlewares/Third_Party/LVGL/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../Middlewares/Third_Party/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/LVGL/src/draw/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/LVGL/src/drivers/display/ft81x/: lv_ft81x.c
    ../Middlewares/Third_Party/LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ../Middlewares/Third_Party/LVGL/src/drivers/display/st7735/: lv_st7735.c
    ../Middlewares/Third_Party/LVGL/src/drivers/display/st7789/: lv_st7789.c
    ../Middlewares/Third_Party/LVGL/src/drivers/display/st7796/: lv_st7796.c
    ../Middlewares/Third_Party/LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middlewares/Third_Party/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middlewares/Third_Party/LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/Third_Party/LVGL/src/font/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../Middlewares/Third_Party/LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/LVGL/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/LVGL/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/LVGL/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/Third_Party/LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/Third_Party/LVGL/src/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Middlewares/Third_Party/LVGL/src/libs/gif/: gif.c
    ../Middlewares/Third_Party/LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/Third_Party/LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/Third_Party/LVGL/src/libs/rle/: lv_rle.c
    ../Middlewares/Third_Party/LVGL/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Middlewares/Third_Party/LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/Third_Party/LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Middlewares/Third_Party/LVGL/src/: lv_init.c
    ../Middlewares/Third_Party/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/Third_Party/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/LVGL/src/others/translation/: lv_translation.c
    ../Middlewares/Third_Party/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/LVGL/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/LVGL/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/LVGL/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/LVGL/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/LVGL/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/LVGL/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/LVGL/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/LVGL/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/Third_Party/LVGL/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/LVGL/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/LVGL/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/LVGL/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/LVGL/src/widgets/gif/: lv_gif.c
    ../Middlewares/Third_Party/LVGL/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/LVGL/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/LVGL/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/LVGL/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/LVGL/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/LVGL/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/LVGL/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/LVGL/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/LVGL/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/LVGL/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/LVGL/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/LVGL/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/LVGL/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/LVGL/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/LVGL/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/LVGL/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/LVGL/src/widgets/win/: lv_win.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1010_CM7_Keil.lib
  group Doc
    ../X-CUBE-AI/App/: gesture_finetuned_generate_report.txt
software components: CMSIS:CORE 4.3.0
